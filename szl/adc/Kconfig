## szl/adc/Kconfig
```kconfig
config SZL_ADC_ENABLE
	bool "Enable SZL_UART"
	default n
	select CONFIG_ADC
	select CONFIG_ADC_ASYNC
```
